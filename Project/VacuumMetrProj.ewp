# IAR project VacuumMetrProj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\CMSIS; ..\libs; ..\Project; ..\; ..\Utilities\FreeRTOS\Source\include; ..\Utilities\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\Tasks; ..\Games; ..\build_number
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\libs; ..\
  OBJCOPY.OOCOutputFile: VacuumMetrProj.bin
  prebuild: cscript.exe ..\build_number\versionfile-gen.vbs ..\build_number\build.c
  ILINK.IlinkOutputFile: VacuumMetrProj.out
  ILINK.IlinkIcfFile: ..\libs\VacuumMetrProj.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group CMSIS
    ../CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group FreeRTOS
    ../Utilities/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
  group FreeRTOS/portable
    ../Utilities/FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../Utilities/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group User
    ../build_number/: build.c
    ./: main.c
    ../libs/: VacuumMetrProj.icf
  group User/FreeRTOS
    ../libs/: FreeRTOSConfig.h TaskPriority.h
  group User/Games
    ../Games/: Snake.c Tetris.c
  group User/libs
    ../libs/: ADC.c BoardConfig.c Buttons.c Configuration.c DISP_Buff.c lcd5110.c stm32f1xx_it.c
  group User/Tasks
    ../Tasks/: Buttons_Task.c LASTLEVELMENU_Task.c Menu_Task.c METER_Task.c SCOPE_Task.c
